options:
  parameters:
    generate_options: qt_gui
    id: carkeyrecord
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: offset
  id: variable
  parameters:
    value: 220e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/goyo/carkey/focus2010/carkey10.record
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/goyo/carkey/focus2010/llave10-binary
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/goyo/carkey/focus2010/carkey10-record-complex
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/goyo/carkey/focus2010/carkey10-mag.record
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '40'
    type: float
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '0.5'
    init: '0'
    low: '0.3'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '30'
    dc_offset_mode0: '2'
    freq0: freq - offset
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq - offset
    fftsize: '512'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_file_sink_2, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_1, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0_0, '0']
- [blocks_keep_one_in_n_1, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_1, '0', blocks_file_sink_0, '0']
- [blocks_threshold_ff_1, '0', blocks_keep_one_in_n_1, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_1, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_throttle_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
